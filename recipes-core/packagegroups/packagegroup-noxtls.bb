# SPDX-License-Identifier: LicenseRef-Argenox-Proprietary

SUMMARY = "NoxTLS command line tools for target images"
LICENSE = "CLOSED"

inherit packagegroup

RDEPENDS:${PN} = "noxtls"
